Commit message: update: cartographer

File: my_robot.urdf (robot description, URDF)
Before this commit: robot my_robot, 2 links, 1 joints
Links:
- removed link lidar_link
- added link laser; visual cylinder length=0.1 radius=0.05
Joints:
- joint lidar_joint: child lidar_link -> laser
